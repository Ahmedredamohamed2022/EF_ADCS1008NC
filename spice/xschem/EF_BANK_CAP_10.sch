v {xschem version=3.1.0 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {devices/ipin.sym} 1090 -995 0 0 {name=p8 lab=VP2}
C {devices/ipin.sym} 1090 -955 0 0 {name=p11 lab=VSS}
C {devices/ipin.sym} 775 -1035 0 0 {name=p19 lab=D0}
C {devices/ipin.sym} 775 -1005 0 0 {name=p20 lab=D1}
C {devices/ipin.sym} 775 -975 0 0 {name=p21 lab=D2}
C {devices/ipin.sym} 775 -945 0 0 {name=p22 lab=D3}
C {devices/ipin.sym} 865 -1035 0 0 {name=p23 lab=D4}
C {devices/ipin.sym} 865 -1005 0 0 {name=p24 lab=D5}
C {devices/ipin.sym} 865 -975 0 0 {name=p25 lab=D6}
C {devices/ipin.sym} 865 -945 0 0 {name=p26 lab=D7}
C {devices/ipin.sym} 960 -1035 0 0 {name=p27 lab=D8}
C {devices/ipin.sym} 960 -1005 0 0 {name=p28 lab=D9}
C {devices/ipin.sym} 1090 -1030 0 0 {name=p6 lab=VP1}
C {devices/lab_pin.sym} 1095 -860 0 0 {name=p1 sig_type=std_logic lab=D0}
C {devices/lab_pin.sym} 1095 -780 0 0 {name=p2 sig_type=std_logic lab=D4}
C {devices/lab_pin.sym} 1095 -900 0 0 {name=p3 sig_type=std_logic lab=VP1}
C {devices/lab_pin.sym} 1095 -840 0 0 {name=p4 sig_type=std_logic lab=D1}
C {devices/lab_pin.sym} 1095 -820 0 0 {name=p5 sig_type=std_logic lab=D2}
C {devices/lab_pin.sym} 1095 -880 0 0 {name=p7 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1095 -800 0 0 {name=p9 sig_type=std_logic lab=D3}
C {devices/lab_pin.sym} 1065 -630 0 0 {name=p10 sig_type=std_logic lab=D8}
C {devices/lab_pin.sym} 1065 -610 0 0 {name=p12 sig_type=std_logic lab=D5}
C {devices/lab_pin.sym} 1065 -590 0 0 {name=p13 sig_type=std_logic lab=D9}
C {devices/lab_pin.sym} 1065 -570 0 0 {name=p14 sig_type=std_logic lab=VP2}
C {devices/lab_pin.sym} 1065 -550 0 0 {name=p15 sig_type=std_logic lab=D6}
C {devices/lab_pin.sym} 1065 -530 0 0 {name=p16 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1065 -510 0 0 {name=p17 sig_type=std_logic lab=D7}
C {devices/lab_pin.sym} 1065 -730 0 0 {name=p18 sig_type=std_logic lab=VP1}
C {devices/lab_pin.sym} 1065 -710 0 0 {name=p29 sig_type=std_logic lab=VP2}
C {devices/lab_pin.sym} 1065 -690 0 0 {name=p30 sig_type=std_logic lab=VSS}
C {Project/Package_IP/package_EF_ADCS1008NC/EF_ADCS1008NC/spice/xschem/EF_LSB_CAP.sym} 1245 -840 0 0 {name=x4}
C {Project/Package_IP/package_EF_ADCS1008NC/EF_ADCS1008NC/spice/xschem/EF_MSB_CAP.sym} 1215 -570 0 0 {name=x1}
C {Project/Package_IP/package_EF_ADCS1008NC/EF_ADCS1008NC/spice/xschem/EF_SC_CAP.sym} 1215 -710 0 0 {name=x2}

v {xschem version=3.1.0 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {EF_DACSCA1001.sym} -170 -1150 0 0 {name=x1}
C {devices/lab_pin.sym} -320 -1030 0 0 {name=p1 sig_type=std_logic lab=EN}
C {devices/lab_pin.sym} -320 -1050 0 0 {name=p2 sig_type=std_logic lab=RST}
C {devices/lab_pin.sym} -320 -1070 0 0 {name=p3 sig_type=std_logic lab=OUT}
C {devices/lab_pin.sym} -20 -1210 0 1 {name=p4 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -20 -1190 0 1 {name=p5 sig_type=std_logic lab=VH}
C {devices/lab_pin.sym} -20 -1170 0 1 {name=p6 sig_type=std_logic lab=VL}
C {devices/lab_pin.sym} -20 -1230 0 1 {name=p7 sig_type=std_logic lab=DVSS}
C {devices/lab_pin.sym} -20 -1250 0 1 {name=p8 sig_type=std_logic lab=DVDD}
C {devices/lab_pin.sym} -20 -1270 0 1 {name=p9 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} -320 -1250 0 0 {name=p10 sig_type=std_logic lab=DATA[1]}
C {devices/lab_pin.sym} -320 -1230 0 0 {name=p11 sig_type=std_logic lab=DATA[2]}
C {devices/lab_pin.sym} -320 -1210 0 0 {name=p12 sig_type=std_logic lab=DATA[3]}
C {devices/lab_pin.sym} -320 -1190 0 0 {name=p13 sig_type=std_logic lab=DATA[4]}
C {devices/lab_pin.sym} -320 -1170 0 0 {name=p14 sig_type=std_logic lab=DATA[5]}
C {devices/lab_pin.sym} -320 -1150 0 0 {name=p15 sig_type=std_logic lab=DATA[6]}
C {devices/lab_pin.sym} -320 -1130 0 0 {name=p16 sig_type=std_logic lab=DATA[7]}
C {devices/lab_pin.sym} -320 -1110 0 0 {name=p17 sig_type=std_logic lab=DATA[8]}
C {devices/lab_pin.sym} -320 -1090 0 0 {name=p18 sig_type=std_logic lab=DATA[9]}
C {devices/lab_pin.sym} -320 -1270 0 0 {name=p19 sig_type=std_logic lab=DATA[0]}
C {EF_R2RVC.sym} -180 -830 0 0 {name=x2}
C {devices/lab_pin.sym} -330 -880 0 0 {name=p20 sig_type=std_logic lab=DVDD}
C {devices/lab_pin.sym} -330 -860 0 0 {name=p21 sig_type=std_logic lab=DVSS}
C {devices/lab_pin.sym} -330 -840 0 0 {name=p22 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} -330 -820 0 0 {name=p23 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -330 -780 0 0 {name=p24 sig_type=std_logic lab=OUT}
C {devices/lab_pin.sym} -30 -880 0 1 {name=p25 sig_type=std_logic lab=CMP}
C {sample_and_hold.sym} -190 -625 0 0 {name=x3}
C {devices/lab_pin.sym} -340 -685 0 0 {name=p28 sig_type=std_logic lab=DVDD}
C {devices/lab_pin.sym} -340 -665 0 0 {name=p29 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} -340 -645 0 0 {name=p35 sig_type=std_logic lab=HOLD}
C {devices/lab_pin.sym} -40 -685 0 1 {name=p36 sig_type=std_logic lab=AHOLD}
C {devices/lab_pin.sym} -340 -625 0 0 {nEame=p37 sig_type=std_logic lab=SELVIN}
C {devices/lab_pin.sym} -340 -605 0 0 {name=p38 sig_type=std_logic lab=EN}
C {devices/lab_pin.sym} -340 -585 0 0 {name=p39 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -340 -565 0 0 {name=p40 sig_type=std_logic lab=DVSS}
C {devices/ipin.sym} -555 -1280 0 0 {name=p61 lab=DATA[0]}
C {devices/ipin.sym} -555 -1250 0 0 {name=p30 lab=DATA[1]}
C {devices/ipin.sym} -555 -1230 0 0 {name=p31 lab=DATA[2]}
C {devices/ipin.sym} -555 -1210 0 0 {name=p32 lab=DATA[3]}
C {devices/ipin.sym} -555 -1190 0 0 {name=p65 lab=DATA[4]}
C {devices/ipin.sym} -555 -1170 0 0 {name=p66 lab=DATA[5]}
C {devices/ipin.sym} -555 -1150 0 0 {name=p67 lab=DATA[6]}
C {devices/ipin.sym} -555 -1130 0 0 {name=p68 lab=DATA[7]}
C {devices/ipin.sym} -555 -1110 0 0 {name=p69 lab=DATA[8]}
C {devices/ipin.sym} -555 -1090 0 0 {name=p70 lab=DATA[9]}
C {devices/ipin.sym} -555 -1020 0 0 {name=p33 lab=RST}
C {devices/ipin.sym} -555 -990 0 0 {name=p34 lab=EN}
C {devices/iopin.sym} 95 -1275 0 0 {name=p41 lab=VDD}
C {devices/iopin.sym} 95 -1245 0 0 {name=p42 lab=DVDD}
C {devices/iopin.sym} 95 -1215 0 0 {name=p43 lab=DVSS}
C {devices/iopin.sym} 95 -1155 0 0 {name=p44 lab=VH}
C {devices/iopin.sym} 95 -1125 0 0 {name=p45 lab=VL}
C {devices/iopin.sym} 95 -1185 0 0 {name=p46 lab=VSS}
C {devices/ipin.sym} -555 -935 0 0 {name=p47 lab=CMP}
C {devices/lab_pin.sym} -330 -800 0 0 {name=p27 sig_type=std_logic lab=AHOLD}
C {devices/ipin.sym} -550 -840 0 0 {name=p49 lab=HOLD}
C {EF_AMUX0801.sym} -660 -550 0 0 {name=x4}
C {devices/lab_pin.sym} -510 -680 0 1 {name=p37 sig_type=std_logic lab=SELVIN}
C {devices/lab_pin.sym} -810 -660 0 0 {name=p51 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} -810 -580 0 0 {name=p52 sig_type=std_logic lab=DVDD}
C {devices/lab_pin.sym} -810 -680 0 0 {name=p53 sig_type=std_logic lab=B[0]}
C {devices/lab_pin.sym} -810 -620 0 0 {name=p54 sig_type=std_logic lab=B[1]}
C {devices/lab_pin.sym} -810 -540 0 0 {name=p55 sig_type=std_logic lab=B[2]}
C {devices/lab_pin.sym} -810 -500 0 0 {name=p56 sig_type=std_logic lab=DVSS}
C {devices/lab_pin.sym} -810 -480 0 0 {name=p57 sig_type=std_logic lab=VIN[2]}
C {devices/lab_pin.sym} -810 -460 0 0 {name=p58 sig_type=std_logic lab=VIN[6]}
C {devices/lab_pin.sym} -810 -440 0 0 {name=p59 sig_type=std_logic lab=VIN[3]}
C {devices/lab_pin.sym} -810 -420 0 0 {name=p60 sig_type=std_logic lab=VIN[7]}
C {devices/lab_pin.sym} -810 -520 0 0 {name=p62 sig_type=std_logic lab=VIN[5]}
C {devices/lab_pin.sym} -810 -560 0 0 {name=p63 sig_type=std_logic lab=VIN[1]}
C {devices/lab_pin.sym} -810 -600 0 0 {name=p64 sig_type=std_logic lab=VIN[4]}
C {devices/lab_pin.sym} -810 -640 0 0 {name=p71 sig_type=std_logic lab=VIN[0]}
C {devices/ipin.sym} -930 -830 0 0 {name=p72 lab=B[0]}
C {devices/ipin.sym} -930 -810 0 0 {name=p73 lab=B[1]}
C {devices/ipin.sym} -930 -790 0 0 {name=p74 lab=B[2]}
C {devices/ipin.sym} -1030 -830 0 0 {name=p75 lab=VIN[0]}
C {devices/ipin.sym} -1030 -800 0 0 {name=p76 lab=VIN[1]}
C {devices/ipin.sym} -1030 -770 0 0 {name=p77 lab=VIN[2]}
C {devices/ipin.sym} -1030 -740 0 0 {name=p78 lab=VIN[3]}
C {devices/ipin.sym} -1030 -710 0 0 {name=p79 lab=VIN[4]}
C {devices/ipin.sym} -1030 -680 0 0 {name=p80 lab=VIN[5]}
C {devices/ipin.sym} -1030 -640 0 0 {name=p81 lab=VIN[6]}
C {devices/ipin.sym} -1030 -610 0 0 {name=p82 lab=VIN[7]}

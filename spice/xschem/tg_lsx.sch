v {xschem version=3.1.0 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {devices/ipin.sym} 1340 -1460 0 0 {name=p5 lab=vdd1p8}
C {devices/ipin.sym} 1340 -1500 0 0 {name=p6 lab=vdd3p3}
C {devices/ipin.sym} 1340 -1405 0 0 {name=p4 lab=vss}
C {devices/lab_pin.sym} 1510 -1380 0 0 {name=p12 sig_type=std_logic lab=l0}
C {devices/ipin.sym} 1245 -1350 0 0 {name=p20 lab=l0}
C {devices/opin.sym} 1340 -1350 0 0 {name=p28 lab=vo}
C {devices/lab_pin.sym} 2180 -1450 0 1 {name=p11 sig_type=std_logic lab=vo}
C {devices/lab_pin.sym} 1880 -1450 0 0 {name=p1 sig_type=std_logic lab=s0}
C {devices/lab_pin.sym} 1880 -1410 0 0 {name=p14 sig_type=std_logic lab=in0}
C {devices/lab_pin.sym} 1880 -1390 0 0 {name=p15 sig_type=std_logic lab=vdd3p3}
C {tg4dx.sym} 2030 -1420 0 0 {name=x9}
C {array_1lsx.sym} 1660 -1410 0 0 {name=x1}
C {devices/lab_pin.sym} 1810 -1440 0 1 {name=p3 sig_type=std_logic lab=s0}
C {devices/lab_pin.sym} 1510 -1440 0 0 {name=p7 sig_type=std_logic lab=vdd3p3}
C {devices/lab_pin.sym} 1510 -1420 0 0 {name=p8 sig_type=std_logic lab=vdd1p8}
C {devices/lab_pin.sym} 1510 -1400 0 0 {name=p9 sig_type=std_logic lab=vss}
C {devices/lab_pin.sym} 1880 -1430 0 0 {name=p2 sig_type=std_logic lab=vss}
C {devices/ipin.sym} 1245 -1310 0 0 {name=p10 lab=in0}

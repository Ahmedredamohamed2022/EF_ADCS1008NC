v {xschem version=3.1.0 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {decoder3to8.sym} 543.75 -257.5 0 0 {name=x1}
C {devices/lab_pin.sym} 493.75 -347.5 0 0 {name=p14 sig_type=std_logic lab=B[0]}
C {devices/lab_pin.sym} 493.75 -387.5 0 0 {name=p15 sig_type=std_logic lab=B[2]}
C {devices/lab_pin.sym} 493.75 -367.5 0 0 {name=p16 sig_type=std_logic lab=B[1]}
C {devices/lab_pin.sym} 593.75 -467.5 1 0 {name=p17 sig_type=std_logic lab=DVDD}
C {devices/lab_pin.sym} 573.75 -467.5 1 0 {name=p18 sig_type=std_logic lab=VSS}
C {devices/ipin.sym} 450 -650 0 0 {name=p5 lab=DVDD}
C {devices/ipin.sym} 450 -690 0 0 {name=p1 lab=VDD}
C {devices/ipin.sym} 450 -595 0 0 {name=p8 lab=VSS}
C {devices/opin.sym} 428.75 -565 0 0 {name=p13 lab=VO}
C {devices/ipin.sym} 555 -695 0 0 {name=p20 lab=B[0]}
C {devices/ipin.sym} 555 -655 0 0 {name=p21 lab=B[1]}
C {devices/ipin.sym} 555 -615 0 0 {name=p52 lab=B[2]}
C {devices/ipin.sym} 230 -659.375 0 0 {name=p60 lab=VIN[0]}
C {devices/ipin.sym} 230 -619.375 0 0 {name=p61 lab=VIN[1]}
C {devices/ipin.sym} 230 -579.375 0 0 {name=p62 lab=VIN[2]}
C {devices/ipin.sym} 230 -539.375 0 0 {name=p63 lab=VIN[3]}
C {devices/ipin.sym} 335 -654.375 0 0 {name=p64 lab=VIN[4]}
C {devices/ipin.sym} 335 -614.375 0 0 {name=p65 lab=VIN[5]}
C {devices/ipin.sym} 335 -574.375 0 0 {name=p66 lab=VIN[6]}
C {devices/ipin.sym} 335 -534.375 0 0 {name=p67 lab=VIN[7]}
C {array_8ls_8tgxx.sym} 962.5 -397.5 0 0 {name=x2}
C {devices/lab_pin.sym} 1112.5 -577.5 0 1 {name=p9 sig_type=std_logic lab=VO}
C {devices/lab_pin.sym} 812.5 -577.5 0 0 {name=p19 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 812.5 -557.5 0 0 {name=p22 sig_type=std_logic lab=DVDD}
C {devices/lab_pin.sym} 812.5 -537.5 0 0 {name=p23 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 812.5 -497.5 0 0 {name=p33 sig_type=std_logic lab=VIN[0]}
C {devices/lab_pin.sym} 812.5 -477.5 0 0 {name=p34 sig_type=std_logic lab=VIN[1]}
C {devices/lab_pin.sym} 812.5 -437.5 0 0 {name=p35 sig_type=std_logic lab=VIN[2]}
C {devices/lab_pin.sym} 812.5 -397.5 0 0 {name=p36 sig_type=std_logic lab=VIN[3]}
C {devices/lab_pin.sym} 812.5 -357.5 0 0 {name=p37 sig_type=std_logic lab=VIN[4]}
C {devices/lab_pin.sym} 812.5 -317.5 0 0 {name=p38 sig_type=std_logic lab=VIN[5]}
C {devices/lab_pin.sym} 812.5 -257.5 0 0 {name=p39 sig_type=std_logic lab=VIN[6]}
C {devices/lab_pin.sym} 812.5 -237.5 0 0 {name=p40 sig_type=std_logic lab=VIN[7]}
C {devices/lab_pin.sym} 812.5 -517.5 0 0 {name=p2 sig_type=std_logic lab=o7l0}
C {devices/lab_pin.sym} 812.5 -457.5 0 0 {name=p3 sig_type=std_logic lab=o6l1}
C {devices/lab_pin.sym} 653.75 -437.5 0 1 {name=p4 sig_type=std_logic lab=o7l0}
C {devices/lab_pin.sym} 653.75 -417.5 0 1 {name=p6 sig_type=std_logic lab=o6l1}
C {devices/lab_pin.sym} 653.75 -397.5 0 1 {name=p7 sig_type=std_logic lab=o5l2}
C {devices/lab_pin.sym} 653.75 -377.5 0 1 {name=p10 sig_type=std_logic lab=o4l3}
C {devices/lab_pin.sym} 653.75 -357.5 0 1 {name=p11 sig_type=std_logic lab=o3l4}
C {devices/lab_pin.sym} 653.75 -337.5 0 1 {name=p12 sig_type=std_logic lab=o2l5}
C {devices/lab_pin.sym} 653.75 -317.5 0 1 {name=p24 sig_type=std_logic lab=o1l6}
C {devices/lab_pin.sym} 653.75 -297.5 0 1 {name=p25 sig_type=std_logic lab=o0l7}
C {devices/lab_pin.sym} 812.5 -417.5 0 0 {name=p26 sig_type=std_logic lab=o5l2}
C {devices/lab_pin.sym} 812.5 -377.5 0 0 {name=p27 sig_type=std_logic lab=o4l3}
C {devices/lab_pin.sym} 812.5 -337.5 0 0 {name=p28 sig_type=std_logic lab=o3l4}
C {devices/lab_pin.sym} 812.5 -297.5 0 0 {name=p29 sig_type=std_logic lab=o2l5}
C {devices/lab_pin.sym} 812.5 -277.5 0 0 {name=p30 sig_type=std_logic lab=o1l6}
C {devices/lab_pin.sym} 812.5 -217.5 0 0 {name=p31 sig_type=std_logic lab=o0l7}

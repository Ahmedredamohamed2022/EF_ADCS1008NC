v {xschem version=3.1.0 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {devices/ipin.sym} 2065 -960 0 0 {name=p30 lab=VP1}
C {devices/ipin.sym} 2065 -930 0 0 {name=p31 lab=VP2}
C {devices/iopin.sym} 2020 -880 0 0 {name=p32 lab=VDD}
C {devices/iopin.sym} 2020 -850 0 0 {name=p33 lab=DVDD}
C {devices/iopin.sym} 2020 -790 0 0 {name=p35 lab=VSS}
C {devices/iopin.sym} 2020 -760 0 0 {name=p36 lab=RST}
C {Project/Package_IP/package_EF_ADCS1008NC/EF_ADCS1008NC/spice/xschem/tg_lsx.sym} 1770 -930 0 0 {name=x4}
C {devices/lab_pin.sym} 1920 -970 0 1 {name=p6 sig_type=std_logic lab=VP1}
C {devices/lab_pin.sym} 1620 -970 0 0 {name=p8 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1620 -950 0 0 {name=p11 sig_type=std_logic lab=DVDD}
C {devices/lab_pin.sym} 1620 -930 0 0 {name=p12 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1620 -910 0 0 {name=p13 sig_type=std_logic lab=RST}
C {devices/lab_pin.sym} 1620 -890 0 0 {name=p14 sig_type=std_logic lab=VSS}
C {Project/Package_IP/package_EF_ADCS1008NC/EF_ADCS1008NC/spice/xschem/tg_lsx.sym} 1760 -770 0 0 {name=x13}
C {devices/lab_pin.sym} 1910 -810 0 1 {name=p125 sig_type=std_logic lab=VP2}
C {devices/lab_pin.sym} 1610 -810 0 0 {name=p126 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1610 -790 0 0 {name=p127 sig_type=std_logic lab=DVDD}
C {devices/lab_pin.sym} 1610 -770 0 0 {name=p128 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1610 -750 0 0 {name=p129 sig_type=std_logic lab=RST}
C {devices/lab_pin.sym} 1610 -730 0 0 {name=p130 sig_type=std_logic lab=VSS}

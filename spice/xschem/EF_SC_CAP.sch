v {xschem version=3.1.0 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1620 -750 0 1 {name=C13 model=cap_mim_m3_1 W=10 L=10 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 1620 -780 3 1 {name=p124 sig_type=std_logic lab=VP2}
C {devices/ipin.sym} 1530 -935 0 0 {name=p8 lab=VP2}
C {devices/ipin.sym} 1530 -895 0 0 {name=p11 lab=VSS}
C {devices/lab_pin.sym} 1620 -720 1 1 {name=p14 sig_type=std_logic lab=VP1}
C {devices/ipin.sym} 1530 -970 0 0 {name=p6 lab=VP1}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1400 -755 0 0 {name=C6 model=cap_mim_m3_1 W=10 L=10 MF=7 spiceprefix=X}
C {devices/lab_pin.sym} 1400 -785 0 0 {name=p29 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1400 -725 3 0 {name=p30 sig_type=std_logic lab=VSS}
